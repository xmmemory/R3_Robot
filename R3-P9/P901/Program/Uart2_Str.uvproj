# Keil uVision project Uart2_Str.uvproj, settings and files
target Uart3_Str (MCS-51)
  device: STC15W204S STC
  cpu: IRAM(0-0xFF) IROM(0-0x0FF8) CLOCK(35000000) MODP2
  output: Uart2_Str +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Application\Header
  group Header
    ./Application/Header/: GPIO.h config.h USART1.h timer.h
  group Source
    ./Application/Source/: main.c GPIO.c USART1.C timer.c
  group StartUp
    ./Application/Startup/: STARTUP.A51
  group Doc
    ./Application/Doc/: readme.txt
